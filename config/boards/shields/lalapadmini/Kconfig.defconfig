## config/boards/shields/lalapadmini/Kconfig.defconfig
```kconfig
if SHIELD_LALAPADMINI

config ZMK_KEYBOARD_NAME
    default "Lalapadmini"

endif
```
